# Keil uVision project zigbee_ota_client_pca10056.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 BOOTLOADER_START_ADDR=NRF_UICR_BOOTLOADER_START_ADDRESS_GET CONFIG_GPIO_AS_PINRESET ENABLE_FEM FLOAT_ABI_HARD KEIL NRF52840_XXAA NRF_DFU_SETTINGS_VERSION=1 SWI_DISABLE0 ZB_TRACE_LEVEL=0 ZB_TRACE_MASK=0 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\..\components\iot\background_dfu;..\..\..\..\..\..\..\..\components\iot\background_dfu\transport;..\..\..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\softdevice\mbr\nrf52840\headers;..\..\..\..\..\..\..\..\components\zigbee\ota;..\..\..;..\..\..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src;..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem;..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\mac_features;..\..\..\..\..\..\..\..\external\nano-pb;..\..\..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\..\..\external\zboss\include;..\..\..\..\..\..\..\..\external\zboss\include\ha;..\..\..\..\..\..\..\..\external\zboss\include\osif;..\..\..\..\..\..\..\..\external\zboss\include\zcl;..\..\..\..\..\..\..\..\external\zboss\osif;..\..\..\..\..\..\..\..\external\zboss\zb_error;..\..\..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET ENABLE_FEM FLOAT_ABI_HARD KEIL NRF52840_XXAA NRF_DFU_SETTINGS_VERSION=1 SWI_DISABLE0 ZB_TRACE_LEVEL=0 ZB_TRACE_MASK=0 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DENABLE_FEM,-DFLOAT_ABI_HARD,-DKEIL,-DNRF52840_XXAA,-DNRF_DFU_SETTINGS_VERSION=1,-DSWI_DISABLE0,-DZB_TRACE_LEVEL=0,-DZB_TRACE_MASK=0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0xff000
  memory RVCT9: RAM 0x20000008 size 0x3fff8
  link misc: --diag_suppress 6330
  group Application
    ../../../../../../../dfu/: dfu_public_key.c
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Zigbee
    ../../../../../../../../external/zboss/lib/keil/: libzboss.lib nrf_radio_driver.lib
    ../../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../../external/zboss/osif/: zb_nrf52840_common.c zb_nrf52840_nrf_logger.c zb_nrf52840_nvram.c zb_nrf52840_ota.c zb_nrf52840_sdk_config_deps.c zb_nrf52840_timer.c
  group nRF_Crypto
    ../../../../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF sw
    ../../../../../../../../components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ../../../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../../../../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_power_clock.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_IoT
    ../../../../../../../../components/iot/background_dfu/: background_dfu_block.c background_dfu_operation.c background_dfu_state.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../../components/libraries/sha256/: sha256.c
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../../../../../../external/nrf_oberon/lib/nrf52/: oberon_short_wchar_2.0.5.lib
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Zigbee
    ../../../../../../../../components/zigbee/ota/: zigbee_dfu_transport.c
  group nRF_micro-ecc
    ../../../../../../../../external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../../../../../../../external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
